# Keil uVision project WLBG_LCD.uvproj, settings and files
target STM_MFRC500 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WLBG_LCD +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\User;..\Libraries\StdPeriph_Driver\inc;..\include;..\BSP\led;..\BSP\beep;..\BSP\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../User/: main.c USART.c stm32f10x_it.c Utils.c delay.c TIM.C key.c crc16.c
    ../BSP/led/: led.c
    ../BSP/beep/: beep.c
    ../BSP/LCD/: lcd.c
  group FWLIB
    ../Libraries/StdPeriph_Driver/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/: stm32f10x.h system_stm32f10x.c
  group DOCS
    ../Docs/: readme.txt
